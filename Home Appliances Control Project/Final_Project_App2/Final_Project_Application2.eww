<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Final_Project_Application\Application_Code\Application_Code.ewp</path>
    </project>
    <batchBuild />
</workspace>
