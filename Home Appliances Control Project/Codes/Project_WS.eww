<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\2_Hands-On_Projects\2_Hands-On_Projects\Lab_Projects\7_Systick_Interrupt\7_Systick_Interrupt\03-Tivaware-Usage\03-Tivaware-Usage.ewp</path>
    </project>
    <batchBuild />
</workspace>
