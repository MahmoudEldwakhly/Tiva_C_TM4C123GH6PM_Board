<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Ex_Timer\Ex_Timer.ewp</path>
    </project>
    <batchBuild />
</workspace>
