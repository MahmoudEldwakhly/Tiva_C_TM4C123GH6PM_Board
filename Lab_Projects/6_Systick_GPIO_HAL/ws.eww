<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01_LED_HAL\01_LED_HAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
